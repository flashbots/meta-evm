include bid-scraper.inc

SRC_URI = "git://github.com/flashbots/rbuilder;protocol=https;branch=develop"
SRCREV = "v1.2.9"

PV = "1.0+git${SRCPV}"
