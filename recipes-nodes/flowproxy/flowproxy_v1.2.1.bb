include flowproxy.inc

SRC_URI = "git://github.com/BuilderNet/FlowProxy;protocol=https;branch=main;lfs=0"
SRCREV = "v1.2.1"

PV = "1.0+git${SRCPV}"
