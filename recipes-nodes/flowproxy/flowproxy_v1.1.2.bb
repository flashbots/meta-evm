include flowproxy.inc

SRC_URI = "git://github.com/BuilderNet/FlowProxy;protocol=https;branch=main"
SRCREV = "v1.1.2"

PV = "1.0+git${SRCPV}"
