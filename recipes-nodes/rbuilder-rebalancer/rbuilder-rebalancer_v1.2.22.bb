include rbuilder-rebalancer.inc

SRC_URI = "git://github.com/flashbots/rbuilder;protocol=https;branch=main"
SRCREV = "v1.2.22"

PV = "1.0+git${SRCPV}"
