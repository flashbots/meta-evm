include reth.inc

FILESEXTRAPATHS:prepend := "${THISDIR}:"
SRC_URI = "git://github.com/paradigmxyz/reth;protocol=https;branch=main"
SRCREV = "v1.4.8"
