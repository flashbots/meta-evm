include reth.inc

FILESEXTRAPATHS:prepend := "${THISDIR}:"
SRC_URI = "git://github.com/paradigmxyz/reth;protocol=https;nobranch=1"
SRCREV = "v1.9.2"
