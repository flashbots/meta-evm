include reth.inc

FILESEXTRAPATHS:prepend := "${THISDIR}:"
SRC_URI = "git://github.com/paradigmxyz/reth;protocol=https;branch=release/v1.8.2"
SRCREV = "9c30bf7af5e0d45deaf5917375c9922c16654b28"
