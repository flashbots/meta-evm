include rbuilder.inc

SRC_URI = "git://github.com/flashbots/rbuilder-operator;protocol=https;branch=main"
SRCREV = "v0.1.6"

PV = "1.0+git${SRCPV}"
