include rbuilder.inc

SRC_URI = "git://github.com/flashbots/rbuilder;protocol=https;nobranch=1"
SRCREV = "v1.2.25"

PV = "1.0+git${SRCPV}"
