include rbuilder.inc

SRC_URI = "git://github.com/flashbots/rbuilder-operator;protocol=https;branch=main"
<<<<<<<< HEAD:recipes-nodes/rbuilder/rbuilder_v1.2.8.bb
SRCREV = "v1.2.8"
========
SRCREV = "v1.2.6"
>>>>>>>> main:recipes-nodes/rbuilder/rbuilder_v1.2.6.bb

PV = "1.0+git${SRCPV}"
