include rbuilder.inc

SRC_URI = "git://github.com/flashbots/rbuilder-operator;protocol=https;branch=main"
SRCREV = "v1.2.4"

PV = "1.0+git${SRCPV}"
